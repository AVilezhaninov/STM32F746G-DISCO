# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx
  ICCARM.CCIncludePath2: ..\source\CMSIS\Include; ..\source\CMSIS\Device\ST\STM32F7xx\Include; ..\source\user\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR.hex
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: ..\source\CMSIS\Device\ST\STM32F7xx\Source\iar\linker\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F746xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS/Device/ST/STM32F7xx/Include
    ../source/CMSIS/Device/ST/STM32F7xx/Include/: stm32f746xx.h stm32f7xx.h system_stm32f7xx.h
  group CMSIS/Device/ST/STM32F7xx/Source
    ../source/CMSIS/Device/ST/STM32F7xx/Source/: system_stm32f7xx.c
  group CMSIS/Device/ST/STM32F7xx/Source/iar
    ../source/CMSIS/Device/ST/STM32F7xx/Source/iar/: startup_stm32f746xx.s
  group CMSIS/Device/ST/STM32F7xx/Source/iar/linker
    ../source/CMSIS/Device/ST/STM32F7xx/Source/iar/linker/: stm32f746xx_flash.icf
  group CMSIS/Include
    ../source/CMSIS/Include/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group user
    ../source/: main.c
  group user/inc
    ../source/user/inc/: rcc.h
  group user/src
    ../source/user/src/: rcc.c
